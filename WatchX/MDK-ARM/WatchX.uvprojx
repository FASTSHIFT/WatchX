# Keil uVision project WatchX.uvprojx, settings and files
target WatchX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WatchX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111,STM32F411xE
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\Core\STM32F4xx_StdPeriph_Driver\inc;..\Core\CMSIS\Device\ST\STM32F4xx\Include;..\WatchX
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Basic
    ../WatchX/Basic/: SysConfig.h main.cpp
  group BSP
    ../WatchX/BSP/: BSP.h BSP_Backlight.cpp BSP_Button.cpp BSP_BMP.cpp BSP_IMU.cpp BSP_Power.cpp BSP_LED.cpp
  group GUI
    ../WatchX/GUI/: DisplayPrivate.h DisplayBasic.cpp DisplayAppWin.cpp DisplayError.cpp lv_ext_func.cpp lv_port_disp.cpp
    ../Libraries/: lv_conf.h
  group GUI/Page
    ../WatchX/GUI/Page/: Page_EXAMPLE.cpp Page_DialPlate.cpp Page_MainMenu.cpp Page_StopWatch.cpp Page_Altitude.cpp Page_BacklightCfg.cpp Page_TimeCfg.cpp Page_About.cpp
  group GUI/IMG
    ../WatchX/GUI/IMG/: ImgBg.c ImgRun.c ImgStopWatch.c ImgMountain.c ImgLight.c ImgButterfly.c ImgTimeCfg.c ImgInfo.c ImgShadowUp.c ImgShadowDown.c ImgPressure.c ImgSettings.c ImgTemperature.c ImgTrigger.c ImgVIFEXTech.c ImgWatchX.c
  group GUI/Font
    ../WatchX/GUI/Font/: HandGotn_26.c HandGotn_20.c HandGotn_14.c Morganite_100.c Morganite_36.c
  group Game
    ../WatchX/Game/: GamePrivate.h Page_Game.cpp GameManager.cpp GameDisp.cpp GameDisp.h
  group Game/Arduboy
    ../WatchX/Game/Arduboy/: Arduboy.cpp
    ../WatchX/Game/Arduboy/audio/: audio.cpp
    ../WatchX/Game/Arduboy/core/: core.cpp
  group Game/Arduboy2
    ../WatchX/Game/Arduboy2/: Arduboy2.cpp Arduboy2Audio.cpp Arduboy2Beep.cpp Arduboy2Core.cpp Sprites.cpp SpritesB.cpp
  group Game/chribocchi
    ../WatchX/Game/chribocchi/: chribocchi.cpp common.h game.cpp logo.cpp MyArduboy.cpp MyArduboy.h title.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/Adafruit_ST7789/: Adafruit_ST7789.cpp
    ../Libraries/Adafruit_BMP180/: Adafruit_BMP085.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/EEPROM_File/: EEPROM_File.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/PageManager/: PageManager.cpp
    ../Libraries/SoftSerial/: SoftSerial.cpp
    ../Libraries/Time/: DateStrings.cpp Time.cpp
  group LittlevGL
    ../Libraries/lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Libraries/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../Libraries/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
    ../Libraries/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Libraries/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../Libraries/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../Libraries/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lv_example
    ../Libraries/lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp WString.cpp Stream.cpp WMath.cpp HardwareSerial.cpp WireBase.cpp Wire.cpp SPI.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c rtc.c
    ../CORE/: delay.c
  group cm_backtrace
    ../Libraries/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../Libraries/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group STM32F4xx_StdPeriph_Driver
    ../Core/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../Core/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s startup_stm32f40xx.s startup_stm32f401xx.s startup_stm32f410xx.s startup_stm32f411xe.s startup_stm32f412xg.s startup_stm32f413_423xx.s startup_stm32f427_437xx.s startup_stm32f427x.s startup_stm32f429_439xx.s startup_stm32f446xx.s startup_stm32f469_479xx.s
  group CMSIS
    ../Core/: system_stm32f4xx.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.2.0
